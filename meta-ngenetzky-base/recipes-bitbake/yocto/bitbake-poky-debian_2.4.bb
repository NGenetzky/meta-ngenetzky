# Copyright (C) 2018 Nathan Genetzky <nathan@genetzky.us>
# Released under the MIT license (see COPYING.MIT for the terms)

require bitbake-poky.inc

PV = "2.4"
PR = "${INC_PR}.0"
