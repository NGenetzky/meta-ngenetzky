require python-resin-rpi-python-picamera.inc
inherit setuptools3
SRCREV = "b283b232cee4bcfd517a62361529921c3c54b80a"
PV = "2017.11.03"
PR = "${INC_PR}.0"
