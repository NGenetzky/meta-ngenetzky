require python-tinydb.inc
inherit setuptools
SRC_URI[md5sum] = "116d9dd1115054674c4eb2b13a09aea2"
SRC_URI[sha256sum] = "96bd60c51a34d7844b89197d7f19a855e249635a4e23dbcf5b892a10e301c032"
