require python-picamera.inc
inherit setuptools
SRC_URI[md5sum] = "97e1e8f0058c7ad079aa457e0a910b2b"
SRC_URI[sha256sum] = "c1d28e578385eac49bdb5f53bdb83c1075c400231593aa7fa246cdb04c67ad00"
