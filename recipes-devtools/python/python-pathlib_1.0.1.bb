require python-pathlib.inc
inherit setuptools
SRC_URI[md5sum] = "5099ed48be9b1ee29b31c82819240537"
SRC_URI[sha256sum] = "6940718dfc3eff4258203ad5021090933e5c04707d5ca8cc9e73c94a7894ea9f"
