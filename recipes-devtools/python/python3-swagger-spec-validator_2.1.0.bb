require python-swagger-spec-validator.inc
inherit setuptools3
SRC_URI[md5sum] = "e13a79ab0a029e706058183e0e22db25"
SRC_URI[sha256sum] = "dc9219c6572ce0def6e1c160ca253c0e7fcde75812628f0c0199334f85bd138e"
