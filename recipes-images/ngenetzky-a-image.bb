DESCRIPTION = "NGenetzky's A Image"
HOMEPAGE = "nathan.genetzky.us"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

PV = "0.0.1"
PR = "r1"

inherit image-from-scratch
IMAGE_FSTYPES += "tar.xz"
