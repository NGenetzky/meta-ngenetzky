require python-connexion.inc
inherit setuptools3
SRC_URI[md5sum] = "08c375fc7ad4d78bc737d8d55563d37d"
SRC_URI[sha256sum] = "23e3984b7c98349da36a9df5359aeba3655c0c861a4d1f4e0914ae89eeebf395"
PR = "${INC_PR}.0"
