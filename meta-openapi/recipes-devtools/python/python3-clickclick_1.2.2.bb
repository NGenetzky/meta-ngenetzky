require python-clickclick.inc
inherit setuptools3
SRC_URI[md5sum] = "77a08b665d1fa381f1853b38aa434ce0"
SRC_URI[sha256sum] = "4a890aaa9c3990cfabd446294eb34e3dc89701101ac7b41c1bff85fc210f6d23"
