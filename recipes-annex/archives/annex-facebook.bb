SUMMARY = ""
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

PV = "1.0"
PR = "r0"

SRCREV = "b2902386f5e46920779471200f9a2d95ff96dad0"
SRC_URI = "\
    git:///data/annex/ngenetzky-archives/;protocol=file;subpath=Facebook/nathansen/;destsuffix=${PN}-${PV} \
"

