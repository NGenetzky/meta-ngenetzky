SUMMARY = "Dockerfile for core-image-minimal"
SECTION = "dockerize"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

PV = "1.0"
PR = "r2"

DOCKERFILE_IMAGE = "core-image-minimal"
inherit dockerfile-image

