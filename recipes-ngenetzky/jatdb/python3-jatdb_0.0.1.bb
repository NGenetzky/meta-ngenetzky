require python-jatdb.inc
PV = "0.0.1-git${SRCPV}"
PR = "${INC_PR}.0"
SRCREV = "c7c5324cb7fbd36a001f49985672b5c2a439d080"
inherit setuptools3

